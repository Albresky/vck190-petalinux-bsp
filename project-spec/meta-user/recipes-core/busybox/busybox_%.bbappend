SRC_URI += "file://user_2026-04-16-13-00-00.cfg \
            file://user_2026-04-16-13-05-00.cfg \
            "

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

